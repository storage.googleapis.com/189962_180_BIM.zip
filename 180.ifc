Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-01-22T16:09:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 22 16:09:45 2020 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{0F41278D-1A06-485D-846B-F9FD20735864}\ifc * Database version: 5507 * Database creation date: Wed Jan 22 16:09:45 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 22 16:09:45 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 22 16:09:45 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 180 Washing machine valve, G3/4xG1/2, 180:180 Washing machine valve, G3/4xG1/2:412399
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints(Type) - ShowerDefaultElevation: 900 mm
Type - Dimensions(Type) - NominalDepth: 90.3308 mm; NominalHeight: 79.5592 mm; NominalWidth: 34 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 180; ConvergoRefNr: 0087-1911-0035-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 29/11/2019
Type - Green Building Properties(Type) - EAN Number: 6414150042447; LVI Number: 6219530; STF Certificate: STF VTT-RTH-00113-11; URL STF: http://static.oras.com/STF/180
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/180; Catalog Drawing URL: http://static.oras.com/catdrw/180; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/180; FDV Document URL: http://www.oras.com/datasheet/180/en/fdv; Group: Washing machine valves; Manufacturer: Oras; Market: INT;FIN;EST;LTU;LVA;RUS; Model: 180 Washing machine valve, G3/4xG1/2; Name_en: 180 Washing machine valve, G3/4xG1/2; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 200 x 150 x 30; Package Weight: 0.398 kg; Product Code: 180; Product Datasheet: http://www.oras.com/datasheet/180/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/180; Product URL: http://static.oras.com/180; Type Name: 180 Washing machine valve, G3/4xG1/2
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: One Inlet Pipe; Connection Size: G3/4xG1/2; Installation and Maintenance: http://static.oras.com/manual/180; Lever Handle: Single Operating Lever; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part;Vacuum breaker; Noise Class: I (ISO 3822); Pressure Loss With Flow 02ls: 55000 Pa; Spare Parts: http://static.oras.com/sp/180
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Utility room; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 180; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 180; Name: 180 Washing machine valve, G3/4xG1/2; ReplacementCost: n/a; Shape: Sculptured; Size: 35x90x80 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 180; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 180 Washing machine valve, G3/4xG1/2
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.014895 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.000260525 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 180: 180 Washing machine valve, G3/4xG1/2; Family and Type: 180: 180 Washing machine valve, G3/4xG1/2; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 180: 180 Washing machine valve, G3/4xG1/2; Type Id: 180: 180 Washing machine valve, G3/4xG1/2; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
